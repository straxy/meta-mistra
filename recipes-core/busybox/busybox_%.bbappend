FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://mkfs.cfg \
"
